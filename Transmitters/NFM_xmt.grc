options:
  parameters:
    author: Barry Duggan
    category: Custom
    comment: |-
      Controlled Envelope
      Narrow-Band FM
      transmitter
    generate_options: qt_gui
    id: NFM_xmt
    output_language: python
    title: NFM_xmt
  states: {}

blocks:
- name: audio_lvl
  id: variable_qtgui_range
  parameters:
    comment: 1,0
    gui_hint: 1,0,1,3
    label: Output Level
    start: '0.5'
    step: '0.1'
    stop: '3.0'
    value: '1.3'
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '4000'
    gain: '1.6'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: pl_enable
  id: variable_qtgui_check_box
  parameters:
    comment: 2,1
    'false': '0'
    gui_hint: 2,1,1,1
    label: PL Tone Enable
    'true': '1'
    type: real
    value: '0'
  states: {}
- name: pl_freq
  id: variable_qtgui_chooser
  parameters:
    comment: 2,0
    gui_hint: 2,0,1,1
    label: PL Tone
    labels: '["0.0", "67.0", "71.9", "74.4", "77.0", "79.7", "82.5", "85.4", "88.5", "91.5", "94.8", "97.4", "100.0", "103.5", "107.2", "110.9", "114.8", "118.8", "123.0", "127.3", "131.8", "136.5", "141.3", "146.2", "151.4", "156.7", "162.2", "167.9", "173.8", "179.9", "186.2", "192.8", "203.5", "210.7", "218.1", "225.7", "233.6", "241.8", "250.3"]'
    num_opts: '0'
    options: '[0.0, 67.0, 71.9, 74.4, 77.0, 79.7, 82.5, 85.4, 88.5, 91.5, 94.8, 97.4, 100.0, 103.5, 107.2, 110.9, 114.8, 118.8, 123.0, 127.3, 131.8, 136.5, 141.3, 146.2, 151.4, 156.7, 162.2, 167.9, 173.8, 179.9, 186.2, 192.8, 203.5, 210.7, 218.1, 225.7, 233.6, 241.8, 250.3]'
    type: real
    value: '0.0'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 0,0
    gui_hint: 0,0,1,3
    label: Mic gain
    start: '0'
    step: '0.1'
    stop: '10.0'
    value: '3.0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.15'
    comment: PL tone generator
    freq: pl_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mic gain
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Output Level
    const: audio_lvl
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: PL enable
    const: pl_enable
    type: float
  states: {}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '1.0'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      gr-cessb contains the modules
      Magnitude Clipper and Peak Stretcher.
      https://github.com/drmpeg/gr-cessb
    note: gr-cessb required
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 3,0
    gui_hint: 3,0,1,3
    size: '32768'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clipper-out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: aud_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clipper-out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: aud_out
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_nbfm_tx_0, '0', mmse_resampler_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_float_0, '0', virtual_sink_1, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '0']
- [cessb_clipper_cc_0, '0', virtual_sink_0, '0']
- [cessb_stretcher_cc_0, '0', fft_filter_xxx_0_1, '0']
- [fft_filter_xxx_0_0, '0', cessb_stretcher_cc_0, '0']
- [fft_filter_xxx_0_0_0, '0', cessb_clipper_cc_0, '0']
- [fft_filter_xxx_0_1, '0', blocks_multiply_const_vxx_1, '0']
- [mmse_resampler_xx_0, '0', zeromq_pub_sink_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0_0, '0']
- [virtual_source_1, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
