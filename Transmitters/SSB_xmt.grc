options:
  parameters:
    author: Barry Duggan
    description: SSB transmitter
    generate_options: qt_gui
    id: SSB_xmt
    output_language: python
    title: SSB_xmt
  states: {}

blocks:
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10.0'
    value: '0.8'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio gain
    const: volume
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: (int)(usrp_rate/samp_rate)
    type: complex
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: channel_filter
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tag1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 576kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0_0, '0', zeromq_pub_sink_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_repeat_0_0, '0']
- [fft_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0_0, '0']

metadata:
  file_format: 1
