options:
  parameters:
    author: Barry Duggan
    comment: |-
      Controlled Envelope
      SSB Transmitter
    description: SSB transmitter
    generate_options: qt_gui
    id: SSB_xmt
    output_language: python
    title: SSB_xmt
  states: {}

blocks:
- name: audio_lvl
  id: variable_qtgui_range
  parameters:
    comment: 1,0
    gui_hint: 1,0,1,3
    label: Output Level
    start: '0.5'
    step: '0.1'
    stop: '3.0'
    value: '1.3'
  states: {}
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.6'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.0145'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 0,0
    gui_hint: 0,0,1,3
    label: Audio gain
    start: '0'
    step: '0.1'
    stop: '10.0'
    value: '3.0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio gain
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio level
    const: audio_lvl
    type: complex
  states: {}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '1.0'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_2
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      gr-cessb contains the modules
      Magnitude Clipper and Peak Stretcher.
      https://github.com/drmpeg/gr-cessb
    note: gr-cessb required
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 2,0
    gui_hint: 2,0,1,3
    size: '32768'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tag1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [cessb_clipper_cc_0, '0', fft_filter_xxx_0_1, '0']
- [cessb_stretcher_cc_0, '0', fft_filter_xxx_0_2, '0']
- [fft_filter_xxx_0, '0', cessb_clipper_cc_0, '0']
- [fft_filter_xxx_0_1, '0', virtual_sink_0, '0']
- [fft_filter_xxx_0_2, '0', blocks_multiply_const_vxx_1, '0']
- [mmse_resampler_xx_0, '0', zeromq_pub_sink_0, '0']
- [virtual_source_0, '0', cessb_stretcher_cc_0, '0']

metadata:
  file_format: 1
