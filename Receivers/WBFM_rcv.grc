options:
  parameters:
    author: Barry Duggan
    description: Broadcast FM
    generate_options: qt_gui
    id: WBFM_rcv
    output_language: python
    title: WBFM_rcv
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: (int)(demod_rate/48000)
  states: {}
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '80000'
    low_cutoff_freq: '-80000'
    samp_rate: demod_rate
    type: complex_band_pass
    width: '20000'
    win: firdes.WIN_HAMMING
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: (int)(samp_rate/rf_decim)
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    orient: Qt.Horizontal
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.2'
    widget: slider
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: (int)(samp_rate/rf_decim)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: rf_decim
    taps: channel_filter
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/rf_decim
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    comment: USRP sample rate = 576kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [fft_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [fft_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0, '0', fft_filter_xxx_0_0, '0']

metadata:
  file_format: 1
