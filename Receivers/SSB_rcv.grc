options:
  parameters:
    author: Barry Duggan
    copyright: CC-BY-SA-4.0
    description: SSB receive
    generate_options: qt_gui
    id: SSB_rcv
    output_language: python
    title: SSB_rcv
  states: {}

blocks:
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '0.96'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sb_sel_r
  id: variable_qtgui_chooser
  parameters:
    comment: 2,0,1,1
    gui_hint: 2,0,1,1
    label: Receive Sideband
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label: Volume (dB)
    start: '-60'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: 10**(volume/20)
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sb_sel_r
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_swapiq_0_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: ((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Numbers under GUI blocks are GUI hints
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: 6,0,1,3
    fc: '0.0'
    fftsize: '1024'
    gui_hint: 6,0,1,3
    showports: 'True'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_selector_0_0, '0', fft_filter_xxx_0, '0']
- [blocks_swapiq_0_0, '0', blocks_selector_0_0, '1']
- [fft_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [mmse_resampler_xx_0, '0', blocks_selector_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_swapiq_0_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0, '0', mmse_resampler_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
