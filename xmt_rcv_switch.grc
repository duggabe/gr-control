options:
  parameters:
    author: Barry Duggan
    description: Station control module
    generate_options: qt_gui
    id: xmt_rcv_switch
    output_language: python
    title: xmt_rcv_switch
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,1
    label: Receive Freq
    type: real
    value: 144.92e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Rcv Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '74.5'
    value: '50'
    widget: slider
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Offset
    labels: '["-600kHz", "0", "+600kHz"]'
    num_opts: '0'
    options: '[-600000, 0, 600000]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: state
  id: guiextra_toggle_button_msg
  parameters:
    gui_hint: 3,2,1,1
    initPressed: 'False'
    label: Transmit
    outputmsgname: value
    pressBackgroundColor: red
    pressFontColor: default
    pressed: '1'
    relBackgroundColor: white
    relFontColor: default
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq+offset
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,2,1,1
    label: Transmit Freq
    type: real
    value: tx_freq
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'False'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nTransmit / Receive Controller\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    reads input from a message port\n    generates control messages\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name='XMT/RCV Control',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('tx_mute'))\n        self.message_port_register_out(pmt.intern('rx_led'))\n        self.message_port_register_out(pmt.intern('ant_sw'))\n        self.message_port_register_out(pmt.intern('pa_sw'))\n        self.message_port_register_out(pmt.intern('rx_mute'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        try:\n            new_val = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n        # print (new_val)\n        if (new_val > 0):\n                # print (\"switching to transmit\")\n\n                # mute receive\n                self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(True))\n\n                # turn off rcv LED\n                self.message_port_pub(pmt.intern('rx_led'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(False)))\n\n                # switch antenna from rcv to xmt\n                # turn on GPIO pin\n\n                # turn on Antenna LED\n                self.message_port_pub(pmt.intern('ant_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(True)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # turn on power amp\n                # turn on GPIO pin\n\n                # turn on Amp LED\n                self.message_port_pub(pmt.intern('pa_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(True)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # unmute transmit (enable Selector)\n                self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))\n\n        else:\n                # print (\"switching to receive\")\n\n                # mute transmit (disable Selector)\n                self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))\n\n                # turn off power amp\n                # turn off GPIO pin\n\n                # turn off Amp LED\n                self.message_port_pub(pmt.intern('pa_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(False)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # switch antenna from xmt to rcv\n                # turn off GPIO pin\n\n                # turn off Antenna LED\n                self.message_port_pub(pmt.intern('ant_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(False)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # unmute receive\n                self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(False))\n\n                # turn on rcv LED\n                self.message_port_pub(pmt.intern('rx_led'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(True)))\n\n\n"
  states: {}
- name: guiextra_ledindicator_0
  id: guiextra_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    label: '"Receive"'
    maxSize: '40'
    offColor: gray
    onColor: lime
    position: '1'
    state: 'True'
    verticalalignment: '1'
  states: {}
- name: guiextra_ledindicator_1
  id: guiextra_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,1,1,1
    label: '"Antenna"'
    maxSize: '40'
    offColor: lime
    onColor: yellow
    position: '1'
    state: 'False'
    verticalalignment: '1'
  states: {}
- name: guiextra_ledindicator_2
  id: guiextra_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,2,1,1
    label: '"Power Amp"'
    maxSize: '40'
    offColor: gray
    onColor: red
    position: '1'
    state: 'False'
    verticalalignment: '1'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '16384'
    cyclic: 'False'
    frequency: int(tx_freq)
    samplerate: samp_rate
    uri: ip:192.168.3.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '16384'
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: ip:192.168.3.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_mute_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [epy_block_0, ant_sw, guiextra_ledindicator_1, state]
- [epy_block_0, pa_sw, guiextra_ledindicator_2, state]
- [epy_block_0, rx_led, guiextra_ledindicator_0, state]
- [epy_block_0, rx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_0, tx_mute, blocks_selector_0, en]
- [iio_pluto_source_0, '0', blocks_mute_xx_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']
- [state, state, epy_block_0, msg_in]
- [zeromq_sub_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
