options:
  parameters:
    author: Barry Duggan
    description: Station control module
    generate_options: qt_gui
    id: xmt_rcv_switch
    output_language: python
    title: xmt_rcv_switch
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 9,0,1,1
    gui_hint: 9,0,1,1
    label: Receive Freq
    type: real
    value: 144.92e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label: Rcv Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '76'
    widget: slider
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    comment: 9,1,1,1
    gui_hint: 9,1,1,1
    label: Offset
    labels: '["-5MHz", "-600kHz", "0", "+600kHz", "+5MHz"]'
    num_opts: '0'
    options: '[-5000000, -600000, 0, 600000, 5000000]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: state
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: 10,2,1,1
    gui_hint: 10,2,1,1
    initPressed: 'False'
    label: Transmit
    pressBackgroundColor: red
    pressFontColor: black
    pressed: '1'
    relFontColor: black
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: |-
      Calculated
      freq+offset
    value: freq+offset
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 2,0,1,3
    gui_hint: 2,0,1,3
    label: Tx gain
    start: '0'
    step: '0.1'
    stop: '1.00'
    value: '0.5'
    widget: slider
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    comment: 9,2,1,1
    gui_hint: 9,2,1,1
    label: Transmit Freq
    type: real
    value: tx_freq
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nTransmit / Receive Controller\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport math\n\n\"\"\"\nState definitions\n    0   idle/rcv\n    1   start xmt\n    2   xmt active\n    3   send tx_eob\n\"\"\"\n\nclass blk(gr.basic_block):\n    \"\"\"\n    reads input from a message port\n    generates control messages\n    \"\"\"\n    def __init__(self):\n        gr.basic_block.__init__(self,\n            name='XMT/RCV Control',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64])\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('rx_led'))\n        self.message_port_register_out(pmt.intern('ant_sw'))\n        self.message_port_register_out(pmt.intern('sw_cmd'))\n        self.message_port_register_out(pmt.intern('pa_sw'))\n        self.message_port_register_out(pmt.intern('rx_mute'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n        self.state = 0      # idle state\n        self.indx = 0       # index for tags\n        self._debug = 0     # set to 1 to turn on diagnostics\n        if (self._debug):\n            print (\"_debug =\", self._debug)\n        self.tag_flags = 1  # bit flags:\n                # 1 - use tx_sob/tx_eob; \n                # 2 - use start tx_time; \n                # 4 - use end tx_time\n        if (self.tag_flags > 0):\n            print (\"tag_flags =\", self.tag_flags)\n\n    def handle_msg(self, msg):\n        try:\n            new_val = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n        if (self._debug):\n            print (\"new_val =\", new_val)\n        if (new_val == 1):\n\n            # (1) mute receive\n            if (self._debug):\n                print (\"t1\")\n            self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(True))\n\n            # (2) turn off rcv LED\n            if (self._debug):\n                print (\"t2\")\n            self.message_port_pub(pmt.intern('rx_led'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n            # (3) send message to relay_sequencer\n            if (self._debug):\n                print (\"t3\")\n            self.message_port_pub(pmt.intern('sw_cmd'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(1)))\n\n            # (4) turn on Antenna LED\n            if (self._debug):\n                print (\"t4\")\n            self.message_port_pub(pmt.intern('ant_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n        elif (new_val == 3):\n\n            # (10) turn on Amp LED\n            if (self._debug):\n                print (\"t10\")\n            self.message_port_pub(pmt.intern('pa_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n            # (11) send tx_sob (state 1)\n            self.state = 1      # start xmt\n\n        elif (new_val == 0):\n\n            # (11) send tx_eob (state 3)\n            self.state = 3      # stop xmt\n\n            # (10) send message to relay_sequencer\n            if (self._debug):\n                print (\"r10\")\n            self.message_port_pub(pmt.intern('sw_cmd'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(0)))\n\n            # (9) turn off Amp LED\n            if (self._debug):\n                print (\"r9\")\n            self.message_port_pub(pmt.intern('pa_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n        elif (new_val == 2):\n\n            # (4) turn off Antenna LED\n            if (self._debug):\n                print (\"r4\")\n            self.message_port_pub(pmt.intern('ant_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n            #     set state 0\n            self.state = 0\n\n            # (2) turn on rcv LED\n            if (self._debug):\n                print (\"r2\")\n            self.message_port_pub(pmt.intern('rx_led'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n            # (1) unmute receive\n            if (self._debug):\n                print (\"r1\")\n            self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(False))\n\n    def general_work(self, input_items, output_items):\n        #buffer references\n        in0 = input_items[0][:len(output_items[0])]\n        out = output_items[0]\n\n        if (self.state == 0):\n            o_len = 0\n\n        elif (self.state == 1):\n            if (self._debug):\n                print (\"state = 1\", self.indx)\n\n            if (self.tag_flags & 1):\n                key1 = pmt.intern(\"tx_sob\")\n                val1 = pmt.PMT_T\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key1,   # Key of the tag\n                    val1    # Value of the tag\n                    )\n\n            if (self.tag_flags & 2):\n                now = time.time()\n                t_tag = now         # + 0.010\n                t_sec = (int)(math.floor(t_tag))\n                t_frac = t_tag - t_sec\n                key2 = pmt.intern(\"tx_time\")\n                val2 = pmt.to_pmt((t_sec, t_frac))\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key2,   # Key of the tag\n                    val2    # Value of the tag\n                    )\n\n            out[:] = in0    # pass thru\n            o_len = len(output_items[0])\n            self.indx += o_len\n            self.state = 2      # xmt active\n\n        elif (self.state == 2):\n            out[:] = in0    # pass thru\n            o_len = len(output_items[0])\n            self.indx += o_len\n\n        elif (self.state == 3):\n            if (self._debug):\n                print (\"state = 3\", self.indx)\n\n            out[:] = in0    # pass thru\n            o_len = len(output_items[0])\n            self.indx += o_len\n\n            if (self.tag_flags & 1):\n                key1 = pmt.intern(\"tx_eob\")\n                val1 = pmt.PMT_T\n                self.add_item_tag(0, # Write to output port 0\n                    (self.indx-1),   # Index of the tag\n                    key1,   # Key of the tag\n                    val1    # Value of the tag\n                    )\n\n            if (self.tag_flags & 4):\n                now = time.time()\n                t_tag = now         # + 0.010\n                t_sec = (int)(math.floor(t_tag))\n                t_frac = t_tag - t_sec\n                key2 = pmt.intern(\"tx_time\")\n                val2 = pmt.to_pmt((t_sec, t_frac))\n                self.add_item_tag(0, # Write to output port 0\n                    (self.indx-1),   # Index of the tag\n                    key2,   # Key of the tag\n                    val2    # Value of the tag\n                    )\n\n            self.state = 0      # stop sending data\n\n        #consume the inputs\n        self.consume(0, len(in0))   # consume port 0 input\n\n        #return produced\n        return (o_len)\n\n"
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Numbers below GUI blocks are the GUI hints
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,1,1,1
    label: '"Antenna"'
    offColor: lime
    onColor: yellow
  states: {}
- name: qtgui_ledindicator_1
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,2,1,1
    label: '"Power Amp"'
    offColor: gray
    onColor: red
  states: {}
- name: qtgui_ledindicator_2
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    label: '"Receive"'
    offColor: gray
    onColor: lime
    state: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '24000'
    comment: 3,0,1,3
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,3
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '200000'
    center_freq0: uhd.tune_request(tx_freq, 300000)
    clock_rate: 30.72e6
    dev_addr: '"send_frame_size=4096"'
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, 180000)
    clock_rate: 30.72e6
    dev_addr: ''
    dev_args: '"recv_buff_size=12288,recv_frame_size=1544"'
    gain0: gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_mute_xx_0, '0', zeromq_pub_sink_0, '0']
- [epy_block_0, '0', blocks_tag_debug_0, '0']
- [epy_block_0, '0', low_pass_filter_0, '0']
- [epy_block_0, ant_sw, qtgui_ledindicator_0, state]
- [epy_block_0, pa_sw, qtgui_ledindicator_1, state]
- [epy_block_0, rx_led, qtgui_ledindicator_2, state]
- [epy_block_0, rx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_0, sw_cmd, zeromq_pub_msg_sink_0, in]
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [state, state, epy_block_0, msg_in]
- [uhd_usrp_sink_0, async_msgs, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', blocks_mute_xx_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0-rc1
