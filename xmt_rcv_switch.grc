options:
  parameters:
    author: Barry Duggan
    description: Station control module
    generate_options: qt_gui
    id: xmt_rcv_switch
    output_language: python
    title: xmt_rcv_switch
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,1
    label: Receive Freq
    type: real
    value: 144.92e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Rcv Gain
    start: '0'
    step: '0.1'
    stop: '1.00'
    value: '0.50'
    widget: slider
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Offset
    labels: '["-600kHz", "0", "+600kHz"]'
    num_opts: '0'
    options: '[-600000, 0, 600000]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: state
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 3,2,1,1
    initPressed: 'False'
    label: Transmit
    pressBackgroundColor: red
    pressFontColor: black
    pressed: '1'
    relFontColor: black
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq+offset
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,2,1,1
    label: Transmit Freq
    type: real
    value: tx_freq
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'False'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nTransmit / Receive Controller\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    reads input from a message port\n    generates control messages\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name='XMT/RCV Control',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('tx_mute'))\n        self.message_port_register_out(pmt.intern('rx_led'))\n        self.message_port_register_out(pmt.intern('ant_sw'))\n        self.message_port_register_out(pmt.intern('pa_sw'))\n        self.message_port_register_out(pmt.intern('rx_mute'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        try:\n            new_val = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n        # print (new_val)\n        if (new_val > 0):\n                # print (\"switching to transmit\")\n\n                # mute receive\n                self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(True))\n\n                # turn off rcv LED\n                self.message_port_pub(pmt.intern('rx_led'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(False)))\n\n                # switch antenna from rcv to xmt\n                # turn on GPIO pin\n\n                # turn on Antenna LED\n                self.message_port_pub(pmt.intern('ant_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(True)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # turn on power amp\n                # turn on GPIO pin\n\n                # turn on Amp LED\n                self.message_port_pub(pmt.intern('pa_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(True)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # unmute transmit (enable Selector)\n                self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))\n\n        else:\n                # print (\"switching to receive\")\n\n                # mute transmit (disable Selector)\n                self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))\n\n                # turn off power amp\n                # turn off GPIO pin\n\n                # turn off Amp LED\n                self.message_port_pub(pmt.intern('pa_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(False)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # switch antenna from xmt to rcv\n                # turn off GPIO pin\n\n                # turn off Antenna LED\n                self.message_port_pub(pmt.intern('ant_sw'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(False)))\n\n                # delay 10 ms\n                time.sleep (0.01)\n\n                # unmute receive\n                self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(False))\n\n                # turn on rcv LED\n                self.message_port_pub(pmt.intern('rx_led'),\n                    pmt.cons(pmt.intern('pressed'),\n                    pmt.from_bool(True)))\n\n\n"
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,1,1,1
    label: '"Antenna"'
    offColor: lime
    onColor: yellow
  states: {}
- name: qtgui_ledindicator_1
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,2,1,1
    label: '"Power Amp"'
    offColor: gray
    onColor: red
  states: {}
- name: qtgui_ledindicator_2
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    label: '"Receive"'
    offColor: gray
    onColor: lime
    state: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,0,1,3
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '200000'
    center_freq0: tx_freq
    dev_args: '"send_buff_size=1024"'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, 180000)
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '"recv_buff_size=32768"'
    gain0: gain
    gain_type0: normalized
    iq_imbal_enb0: '""'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_mute_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [epy_block_0, ant_sw, qtgui_ledindicator_0, state]
- [epy_block_0, pa_sw, qtgui_ledindicator_1, state]
- [epy_block_0, rx_led, qtgui_ledindicator_2, state]
- [epy_block_0, rx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_0, tx_mute, blocks_selector_0, en]
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', uhd_usrp_sink_0, '0']
- [state, state, epy_block_0, msg_in]
- [uhd_usrp_source_0, '0', blocks_mute_xx_0, '0']
- [zeromq_sub_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
