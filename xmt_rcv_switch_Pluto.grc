options:
  parameters:
    author: Barry Duggan
    description: Pluto Station control module
    generate_options: qt_gui
    id: xmt_rcv_switch_Pluto
    output_language: python
    title: xmt_rcv_switch_Pluto
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 9,0
    gui_hint: 9,0,1,1
    label: Receive Freq
    type: real
    value: 432.2e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 1,0
    gui_hint: 1,0,1,3
    label: Rcv Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '50'
    widget: slider
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    comment: 9,1
    gui_hint: 9,1,1,1
    label: Offset
    labels: '["-5MHz", "-600kHz", "0", "+600kHz", "+5MHz"]'
    num_opts: '0'
    options: '[-5000000, -600000, 0, 600000, 5000000]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    comment: 2,0
    gui_hint: 2,0,1,3
    label: Tx Attenuation
    start: '0'
    step: '1'
    stop: '89'
    value: '0'
    widget: slider
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq+offset
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    comment: 9,2
    gui_hint: 9,2,1,1
    label: Transmit Freq
    type: real
    value: tx_freq
  states: {}
- name: variable_qtgui_toggle_button_msg_0
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 3,2,1,1
    initPressed: 'False'
    label: Transmit
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: white
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'False'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nTransmit / Receive Controller\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    reads input from a message port\n    generates control messages\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name='XMT/RCV Control',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('burst'))\n        self.message_port_register_out(pmt.intern('tx_mute'))\n        self.message_port_register_out(pmt.intern('rx_led'))\n        self.message_port_register_out(pmt.intern('ant_sw'))\n        self.message_port_register_out(pmt.intern('sw_cmd'))\n        self.message_port_register_out(pmt.intern('pa_sw'))\n        self.message_port_register_out(pmt.intern('rx_mute'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        _debug = 0          # set to zero to turn off diagnostics\n\n        try:\n            new_val = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n        if (_debug):\n            print (\"new_val =\", new_val)\n        if (new_val == 1):\n\n            # (1) mute receive\n            if (_debug):\n                print (\"t1\")\n            self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(True))\n\n            # (2) turn off rcv LED\n            if (_debug):\n                print (\"t2\")\n            self.message_port_pub(pmt.intern('rx_led'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n            # (3) send message to relay_sequencer\n            if (_debug):\n                print (\"t3\")\n            self.message_port_pub(pmt.intern('sw_cmd'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(1)))\n\n            # (4) turn on Antenna LED\n            if (_debug):\n                print (\"t4\")\n            self.message_port_pub(pmt.intern('ant_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n        elif (new_val == 3):\n\n            # (9) turn on Amp LED\n            if (_debug):\n                print (\"t9\")\n            self.message_port_pub(pmt.intern('pa_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n            # (10) delay 10 ms\n            time.sleep (0.01)\n\n            # (11) unmute transmit (enable Selector)\n            if (_debug):\n                print (\"t11\")\n            self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))\n\n            # (12) send message to burst tagger\n            if (_debug):\n                print (\"t12\")\n            self.message_port_pub(pmt.intern('burst'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(1)))\n\n        elif (new_val == 0):\n\n            # (12) send message to burst tagger\n            if (_debug):\n                print (\"t12\")\n            self.message_port_pub(pmt.intern('burst'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(0)))\n\n            # (11.5) delay 5 ms\n            time.sleep (0.005)\n\n            # (11) mute transmit (disable Selector)\n            if (_debug):\n                print (\"r11\")\n            self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))\n\n            # (10) send message to relay_sequencer\n            if (_debug):\n                print (\"r10\")\n            self.message_port_pub(pmt.intern('sw_cmd'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(0)))\n\n            # (9) turn off Amp LED\n            if (_debug):\n                print (\"r9\")\n            self.message_port_pub(pmt.intern('pa_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n        elif (new_val == 2):\n\n            # (4) turn off Antenna LED\n            if (_debug):\n                print (\"r4\")\n            self.message_port_pub(pmt.intern('ant_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n            # (3) delay 10 ms\n            time.sleep (0.01)\n\n            # (2) turn on rcv LED\n            if (_debug):\n                print (\"r2\")\n            self.message_port_pub(pmt.intern('rx_led'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n            # unmute receive\n            if (_debug):\n                print (\"r1\")\n            self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(False))\n\n\n"
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    fpass: samp_rate/4
    frequency: int(tx_freq)
    fstop: samp_rate/3
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    fpass: samp_rate/4
    frequency: int(freq)
    fstop: samp_rate/3
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      All I/O sample rates have been
      set to 768kHz for USRP and Pluto
    note: I/O sample rates = 768kHz
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,2,1,1
    label: '"Power Amp"'
    offColor: gray
    onColor: red
  states: {}
- name: qtgui_ledindicator_1
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,1,1,1
    label: '"Antenna"'
    offColor: lime
    onColor: yellow
  states: {}
- name: qtgui_ledindicator_2
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,0,1,1
    label: '"Receive"'
    offColor: gray
    onColor: lime
    state: 'True'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_mute_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [epy_block_0, ant_sw, qtgui_ledindicator_1, state]
- [epy_block_0, pa_sw, qtgui_ledindicator_0, state]
- [epy_block_0, rx_led, qtgui_ledindicator_2, state]
- [epy_block_0, rx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_0, sw_cmd, zeromq_pub_msg_sink_0, in]
- [epy_block_0, tx_mute, blocks_selector_0, en]
- [iio_pluto_source_0, '0', blocks_mute_xx_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']
- [variable_qtgui_toggle_button_msg_0, state, epy_block_0, msg_in]
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_sub_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
